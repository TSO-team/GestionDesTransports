<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\247-637 S-0008 college.ewp</path>
  </project>
  <batchBuild/>
</workspace>


