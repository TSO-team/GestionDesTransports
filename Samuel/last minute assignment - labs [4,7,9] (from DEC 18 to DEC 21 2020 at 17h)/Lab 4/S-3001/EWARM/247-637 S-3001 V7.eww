<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\247-637 S-3001 V7.ewp</path>
  </project>
  <batchBuild />
</workspace>
