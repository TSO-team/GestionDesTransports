# IAR project 247-637 S-0008 college.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Maxim (Dallas Semiconductor)\DS89C450.i51
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  ICC8051.CCDefines: OPTION_COMPILE_AVEC_IAR
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 1
  XLINK.XclFile: lnk51ew_DS89C450.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  group SOURCE
    ../SOURCE/: interfaceB1.c interfaceS0009.c interfaceT1.c main.c piloteIOB1.c piloteIOT1.c piloteTimer1Mode2.c piloteTimer2AutoReload.c piloteUART0.c piloteUART1.c processusBoutonConnecte.c processusClignotant.c serviceBaseDeTemps.c serviceProtocole637.c
